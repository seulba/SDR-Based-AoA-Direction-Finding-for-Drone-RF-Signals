options:
  parameters:
    generate_options: qt_gui
    id: MUSIC_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: C
  id: variable
  parameters:
    value: 3e8
  states: {}
- name: ant_spacing
  id: variable
  parameters:
    value: '0.065'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: d_over_lambda
  id: variable
  parameters:
    value: ant_spacing / wavelength
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: scan_pts
  id: variable
  parameters:
    value: '181'
  states: {}
- name: vec_len
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: wavelength
  id: variable
  parameters:
    value: C / center_freq
  states: {}
- name: aoa_autocorrelate_0
  id: aoa_autocorrelate
  parameters:
    avg_method: '0'
    num_inputs: '2'
    overlap_size: '512'
    snapshot_size: '2048'
  states: {}
- name: aoa_music_lin_array_0
  id: aoa_music_lin_array
  parameters:
    norm_spacing: '0.5'
    num_inputs: '2'
    num_targets: '1'
    pspectrum_len: '181'
  states: {}
- name: aoa_root_music_linear_array_0
  id: aoa_root_music_linear_array
  parameters:
    norm_spacing: '0.5'
    num_inputs: '2'
    num_targets: '1'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '180'
    min: '0'
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    name: MUSIC Spectrum
    vlen: scan_pts
    x_start: '0'
    x_step: 180/(scan_pts-1)
    ymax: '1'
    ymin: '-20'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: center_freq
    center_freq1: center_freq
    gain0: rx_gain
    gain1: rx_gain
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [aoa_autocorrelate_0, '0', aoa_music_lin_array_0, '0']
- [aoa_autocorrelate_0, '0', aoa_root_music_linear_array_0, '0']
- [aoa_music_lin_array_0, '0', qtgui_vector_sink_f_0, '0']
- [aoa_root_music_linear_array_0, '0', qtgui_number_sink_0, '0']
- [dc_blocker_xx_0, '0', aoa_autocorrelate_0, '0']
- [dc_blocker_xx_0_0, '0', aoa_autocorrelate_0, '1']
- [uhd_usrp_source_0, '0', dc_blocker_xx_0, '0']
- [uhd_usrp_source_0, '1', dc_blocker_xx_0_0, '0']

metadata:
  file_format: 1
