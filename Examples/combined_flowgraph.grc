options:
  parameters:
    generate_options: qt_gui
    id: MUSIC_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: C
  id: variable
  parameters:
    value: 3e8
  states: {}
- name: ant_spacing
  id: variable
  parameters:
    value: '0.065'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: d_over_lambda
  id: variable
  parameters:
    value: ant_spacing / wavelength
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: scan_pts
  id: variable
  parameters:
    value: '181'
  states: {}
- name: vec_len
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: wavelength
  id: variable
  parameters:
    value: C / center_freq
  states: {}
- name: aoa_autocorrelate_0
  id: aoa_autocorrelate
  parameters:
    avg_method: '1'
    num_inputs: '2'
    overlap_size: '512'
    snapshot_size: '2048'
  states: {}
- name: aoa_music_lin_array_0
  id: aoa_music_lin_array
  parameters:
    norm_spacing: '0.5'
    num_inputs: '2'
    num_targets: '1'
    pspectrum_len: '181'
  states: {}
- name: aoa_root_music_linear_array_0
  id: aoa_root_music_linear_array
  parameters:
    norm_spacing: '0.5'
    num_inputs: '2'
    num_targets: '1'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '512'
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '512'
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, vec_len=512, num_scan=181, center_freq=2.4e9, d=0.065, phase_cal=0.0, update_every=5):
              self.vec_len = int(vec_len)
              self.num_scan = int(num_scan)
              self.center_freq = float(center_freq)
              self.d = float(d)
              self.phase_cal = float(phase_cal)
              self.update_every = int(update_every)

              self.c = 299792458.0
              self.Nr = 2

              gr.sync_block.__init__(
                  self,
                  name="B210_2ch_MVDR_DOA_cal",
                  in_sig=[(np.complex64, self.vec_len), (np.complex64, self.vec_len)],
                  out_sig=[
                      (np.float32, self.num_scan),
                      (np.float32, self.num_scan)
                  ]
              )

              self.theta_scan = np.linspace(-np.pi/2, np.pi/2, self.num_scan)

              self.counter = 0
              self.last_conv = np.zeros(self.num_scan, dtype=np.float32)
              self.last_mvdr = np.zeros(self.num_scan, dtype=np.float32)

          def steering_vector(self, theta):
              n = np.arange(self.Nr)
              s = np.exp(-2j * np.pi * self.d * self.center_freq / self.c * n * np.sin(theta))
              return s.reshape(-1, 1)

          def covariance_matrix(self, x):
              R = (x @ x.conj().T) / x.shape[1]
              R += 1e-6 * np.eye(self.Nr)
              return R

          def conventional_spectrum(self, R, theta):
              s = self.steering_vector(theta)
              val = np.real((s.conj().T @ R @ s).item())
              return max(val, 1e-12)

          def mvdr_spectrum(self, Rinv, theta):
              s = self.steering_vector(theta)
              denom = np.real((s.conj().T @ Rinv @ s).item())
              return max(1.0 / max(denom, 1e-12), 1e-12)

          def work(self, input_items, output_items):
              in0 = input_items[0]
              in1 = input_items[1]
              out_conv = output_items[0]
              out_mvdr = output_items[1]

              n_vectors = min(len(in0), len(in1), len(out_conv), len(out_mvdr))

              for k in range(n_vectors):
                  self.counter += 1

                  if (self.counter % self.update_every) != 0:
                      out_conv[k][:] = self.last_conv
                      out_mvdr[k][:] = self.last_mvdr
                      continue

                  ch0 = in0[k]
                  ch1 = in1[k]

                  ch1_corr = ch1 * np.exp(1j * self.phase_cal)
                  x = np.vstack([ch0, ch1_corr]).astype(np.complex128)

                  R = self.covariance_matrix(x)
                  Rinv = np.linalg.pinv(R)

                  doa_conv = np.zeros(self.num_scan, dtype=np.float64)
                  doa_mvdr = np.zeros(self.num_scan, dtype=np.float64)

                  for i, theta in enumerate(self.theta_scan):
                      doa_conv[i] = self.conventional_spectrum(R, theta)
                      doa_mvdr[i] = self.mvdr_spectrum(Rinv, theta)

                  doa_conv_db = 10.0 * np.log10(doa_conv + 1e-12)
                  doa_mvdr_db = 10.0 * np.log10(doa_mvdr + 1e-12)

                  doa_conv_db -= np.max(doa_conv_db)
                  doa_mvdr_db -= np.max(doa_mvdr_db)

                  self.last_conv = doa_conv_db.astype(np.float32)
                  self.last_mvdr = doa_mvdr_db.astype(np.float32)

                  out_conv[k][:] = self.last_conv
                  out_mvdr[k][:] = self.last_mvdr

              return n_vectors
    center_freq: center_freq
    d: 299792458/(2*center_freq)
    num_scan: '181'
    phase_cal: '0.0'
    update_every: '5'
    vec_len: '512'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '180'
    min: '0'
    name: ROOT-MUSIC
    type: float
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: Tab 0
    num_tabs: '1'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    gui_hint: 'qtgui_tab_widget_0@0: [1,0,1,1]'
    name: MUSIC Spectrum
    vlen: scan_pts
    x_start: '0'
    x_step: 180/(scan_pts-1)
    ymax: '1'
    ymin: '-20'
  states: {}
- name: qtgui_vector_sink_f_1
  id: qtgui_vector_sink_f
  parameters:
    gui_hint: 'qtgui_tab_widget_0@0: [0,0,1,1]'
    name: Conventional
    vlen: '181'
    x_start: '0'
    x_step: 180/(181-1)
    ymax: '0'
    ymin: '-30'
  states: {}
- name: qtgui_vector_sink_f_1_0
  id: qtgui_vector_sink_f
  parameters:
    gui_hint: 'qtgui_tab_widget_0@0: [0,1,1,1]'
    name: MVDR
    vlen: '181'
    x_start: '0'
    x_step: 180/(181-1)
    ymax: '0'
    ymin: '-30'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    bw0: samp_rate
    bw1: samp_rate
    center_freq0: center_freq
    center_freq1: center_freq
    gain0: rx_gain
    gain1: rx_gain
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [aoa_autocorrelate_0, '0', aoa_music_lin_array_0, '0']
- [aoa_autocorrelate_0, '0', aoa_root_music_linear_array_0, '0']
- [aoa_music_lin_array_0, '0', qtgui_vector_sink_f_0, '0']
- [aoa_root_music_linear_array_0, '0', qtgui_number_sink_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_0, '0']
- [blocks_stream_to_vector_1, '0', epy_block_0, '1']
- [dc_blocker_xx_0, '0', aoa_autocorrelate_0, '0']
- [dc_blocker_xx_0_0, '0', aoa_autocorrelate_0, '1']
- [epy_block_0, '0', qtgui_vector_sink_f_1, '0']
- [epy_block_0, '1', qtgui_vector_sink_f_1_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0, '0', dc_blocker_xx_0, '0']
- [uhd_usrp_source_0, '1', blocks_stream_to_vector_1, '0']
- [uhd_usrp_source_0, '1', dc_blocker_xx_0_0, '0']

metadata:
  file_format: 1
